# Keil uVision project AD-30.uvprojx, settings and files
target AD-30 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AD-30 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;.\inc;..\MQTT\MQTTPacket;..\EC20;..\MQTT\nordic;..\cJSON;..\RTC;..\HARDWARE\MOTO;..\HARDWARE\WDG;..\HARDWARE\w5500\Application\loopback;..\HARDWARE\w5500\Ethernet;..\HARDWARE\w5500\Ethernet\W5500;..\HARDWARE\w5500\Internet\DHCP;..\HARDWARE\cJSON;..\HARDWARE\MALLOC;..\HARDWARE\w5500\Internet\DNS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./src/: fifo.c main.c prjlib.c stm32f10x_it.c system_stm32f10x.c timer.c analysis_protocol.c ananlysis_data.c schedule.c DS1302.C m_w5500_conf.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MOTO/: moto.c
    ../HARDWARE/WDG/: wdg.c
    ./src/: spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_spi.c
  group README
    ../: README.TXT
  group RTC
    ../RTC/: rtc.c
  group w5500
    ../HARDWARE/w5500/Application/loopback/: loopback.c
    ../HARDWARE/w5500/Ethernet/: socket.c wizchip_conf.c
    ../HARDWARE/w5500/Ethernet/W5500/: w5500.c
    ../HARDWARE/w5500/Internet/DHCP/: dhcp.c
    ../HARDWARE/w5500/Internet/DNS/: dns.c
  group Cjson
    ../HARDWARE/cJSON/: cJSON.c
    ../HARDWARE/MALLOC/: malloc.c
