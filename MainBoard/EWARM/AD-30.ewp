# IAR project AD-30.ewp, settings and files
configuration AD-30 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../user_app/inc; ../user_app/motor; ../w5500; ../w5500/common; ../w5500/ethernet; ../w5500/ethernet/socket; ../w5500/ethernet/socket_bsd; ../w5500/ethernet/w5500; ../w5500/host; ../w5500/internet; ../MQTT; ../MQTT/FreeRTOS; ../MQTT/MQTTPacket; ../CJSON
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: AD-30.hex
  ILINK.IlinkOutputFile: AD-30.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: freertos.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group cjson
    ../cJSON/: cJSON.c cJSON.h
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group motor
    ../user_app/motor/: motor.c
  group MQTT
    ../MQTT/: MQTTClient.c
    ../MQTT/FreeRTOS/: MQTTFreeRTOS.c
  group MQTT/pcaket
    ../MQTT/MQTTPacket/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group user_app
    ../user_app/src/: console.c DataSave.c dfu.c http.c MQTT_Conn.c prjlib.c protocol.c rfid.c rtc_ext.c spi_flash.c system.c uart.c
  group W5500/comon
    ../w5500/common/: common.h util.c util.h
  group W5500/ethernet
    ../w5500/ethernet/: wizchip_conf.c
  group W5500/ethernet/socket
    ../w5500/ethernet/socket/: netctrl.c netctrl.h socket.c socket.h sockutil.c sockutil.h
  group W5500/ethernet/socket_bsd
    ../w5500/ethernet/socket_bsd/: socket_bsd.c socket_bsd.h
  group W5500/ethernet/w5500
    ../w5500/ethernet/w5500/: w5500.c w5500.h
  group W5500/host
    ../w5500/host/: w5500_comm.c
  group W5500/internet
    ../w5500/internet/DHCP/: dhcp.c
    ../w5500/internet/DNS/: dns.c
